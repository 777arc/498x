options:
  parameters:
    generate_options: qt_gui
    id: audio_equalizer
  states: {}

blocks:
- name: high
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: High
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: low
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Low
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: med
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Med
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/marc/498x/thunderclouds_clip.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 3,1,1,1
    showports: 'True'
    type: float
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 4,1,1,1
    showports: 'True'
    type: float
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 5,1,1,1
    showports: 'True'
    type: float
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 3,0,3,1
    size: '1000'
    srate: samp_rate
    type: float
    update_time: '0.05'
  states: {}

connections:
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
